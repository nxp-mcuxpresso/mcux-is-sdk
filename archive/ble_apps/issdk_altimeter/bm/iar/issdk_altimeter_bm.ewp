# IAR project issdk_altimeter_bm.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKW41Z512xxx4 NXP MKW41Z512xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; CPU_MKW41Z512VHT4; FRDM_KW41Z; FREEDOM
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.PreInclude: ../../../../../../../boards/frdmkw41z/wireless_examples/bluetooth/wireless_uart/bm/app_preinclude.h
  ICCARM.CCIncludePath2: ../../../../../../../CMSIS/Include; ../../../../../../../devices; ../../../../../../../middleware/wireless/framework_5.3.3/OSAbstraction/Interface; ..; ../../../../../../../middleware/wireless/framework_5.3.3/Flash/Internal; ../../../../../../../middleware/wireless/framework_5.3.3/GPIO; ../../../../../../../middleware/wireless/framework_5.3.3/Keyboard/Interface; ../../../../../../../middleware/wireless/framework_5.3.3/LED/Interface; ../../../../../../../middleware/wireless/framework_5.3.3/Common; ../../../../../../../middleware/wireless/framework_5.3.3/MemManager/Interface; ../../../../../../../middleware/wireless/framework_5.3.3/Messaging/Interface; ../../../../../../../middleware/wireless/framework_5.3.3/Panic/Interface; ../../../../../../../middleware/wireless/framework_5.3.3/RNG/Interface; ../../../../../../../middleware/wireless/framework_5.3.3/NVM/Interface; ../../../../../../../middleware/wireless/framework_5.3.3/NVM/Source; ../../../../../../../middleware/wireless/framework_5.3.3/SerialManager/Interface; ../../../../../../../middleware/wireless/framework_5.3.3/SerialManager/Source; ../../../../../../../middleware/wireless/framework_5.3.3/Shell/Interface; ../../../../../../../middleware/wireless/framework_5.3.3/TimersManager/Interface; ../../../../../../../middleware/wireless/framework_5.3.3/TimersManager/Source; ../../../../../../../middleware/wireless/framework_5.3.3/ModuleInfo; ../../../../../../../middleware/wireless/framework_5.3.3/FunctionLib; ../../../../../../../middleware/wireless/framework_5.3.3/Lists; ../../../../../../../middleware/wireless/framework_5.3.3/SecLib; ../../../../../../../middleware/wireless/bluetooth_1.2.3/host/interface; ../../../../../../../middleware/wireless/bluetooth_1.2.3/host/config; ../../../../../../../middleware/wireless/bluetooth_1.2.3/application/common; ../../../../../../../middleware/wireless/bluetooth_1.2.3/controller/interface; ../../../../../../../middleware/wireless/bluetooth_1.2.3/hci_transport/interface; ../../../../../../../middleware/wireless/bluetooth_1.2.3/application/common/gatt_db; ../../../../../../../middleware/wireless/bluetooth_1.2.3/application/common/gatt_db/macros; ../../../../../../../middleware/wireless/bluetooth_1.2.3/profiles/battery; ../../../../../../../middleware/wireless/bluetooth_1.2.3/profiles/device_info; ../../../../../../../middleware/wireless/bluetooth_1.2.3/profiles/wireless_uart; ../../../../../../../middleware/wireless/framework_5.3.3/MWSCoexistence/Interface; ../..; ../../../../../../../devices/MKW41Z4/drivers; ../../../../../../../middleware/wireless/framework_5.3.3/DCDC/Interface; ../../../../../../../middleware/wireless/framework_5.3.3/XCVR/MKW41Z4; ../../../../../../../devices/MKW41Z4; ../../../../../../../devices/MKW41Z4/utilities; ..\..\..\..\..\..\..\CMSIS\Driver\Include; ..\..\..\..\..\..\..\middleware\issdk_1.5\boardkit\frdm-kw41z; ..\..\..\..\..\..\..\middleware\issdk_1.5\boardkit\frdm-kw41z\frdm-stbc-agmp03; ..\..\..\..\..\..\..\middleware\issdk_1.5\drivers\gpio; ..\..\..\..\..\..\..\middleware\issdk_1.5\drivers\systick; ..\..\..\..\..\..\..\middleware\issdk_1.5\sensors; ..\..\..\..\..\..\..\devices\MKW41Z4\cmsis_drivers; ..\..\..\..\..\..\..\middleware\issdk_1.5\algorithms\pedometer\include; ..\..\..\..\..\..\..\middleware\issdk_1.5\algorithms\pedometer\include\libinclude
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  OBJCOPY.OOCOutputFile: issdk_altimeter_bm.bin
  ILINK.IlinkOutputFile: issdk_altimeter_bm.out
  ILINK.IlinkConfigDefines: gUseNVMLink_d=1
  ILINK.IlinkIcfFile: MKW41Z512xxx4_connectivity.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../../middleware/wireless/bluetooth_1.2.3/host/lib/lib_ble_4-2_host_cm0p.a; ../../../../../../../middleware/wireless/bluetooth_1.2.3/controller/lib/lib_ble_kw41z_controller.a; ../../../../../../../middleware/wireless/framework_5.3.3/SecLib/lib_crypto_m0.a; ..\..\..\..\..\..\..\middleware\issdk_1.5\algorithms\pedometer\lib\LibPedometer_m0.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKW41Z512VHT4; FRDM_KW41Z; FREEDOM
  ICCARM.CCIncludePath2: ../../../../../../../CMSIS/Include; ../../../../../../../devices; ../../../../../../../middleware/wireless/framework_5.3.3/OSAbstraction/Interface; ..; ../../../../../../../middleware/wireless/framework_5.3.3/Flash/Internal; ../../../../../../../middleware/wireless/framework_5.3.3/GPIO; ../../../../../../../middleware/wireless/framework_5.3.3/Keyboard/Interface; ../../../../../../../middleware/wireless/framework_5.3.3/LED/Interface; ../../../../../../../middleware/wireless/framework_5.3.3/Common; ../../../../../../../middleware/wireless/framework_5.3.3/MemManager/Interface; ../../../../../../../middleware/wireless/framework_5.3.3/Messaging/Interface; ../../../../../../../middleware/wireless/framework_5.3.3/Panic/Interface; ../../../../../../../middleware/wireless/framework_5.3.3/RNG/Interface; ../../../../../../../middleware/wireless/framework_5.3.3/NVM/Interface; ../../../../../../../middleware/wireless/framework_5.3.3/NVM/Source; ../../../../../../../middleware/wireless/framework_5.3.3/SerialManager/Interface; ../../../../../../../middleware/wireless/framework_5.3.3/SerialManager/Source; ../../../../../../../middleware/wireless/framework_5.3.3/Shell/Interface; ../../../../../../../middleware/wireless/framework_5.3.3/TimersManager/Interface; ../../../../../../../middleware/wireless/framework_5.3.3/TimersManager/Source; ../../../../../../../middleware/wireless/framework_5.3.3/ModuleInfo; ../../../../../../../middleware/wireless/framework_5.3.3/FunctionLib; ../../../../../../../middleware/wireless/framework_5.3.3/Lists; ../../../../../../../middleware/wireless/framework_5.3.3/SecLib; ../../../../../../../middleware/wireless/bluetooth_1.2.3/host/interface; ../../../../../../../middleware/wireless/bluetooth_1.2.3/host/config; ../../../../../../../middleware/wireless/bluetooth_1.2.3/application/common; ../../../../../../../middleware/wireless/bluetooth_1.2.3/controller/interface; ../../../../../../../middleware/wireless/bluetooth_1.2.3/hci_transport/interface; ../../../../../../../middleware/wireless/bluetooth_1.2.3/application/common/gatt_db; ../../../../../../../middleware/wireless/bluetooth_1.2.3/application/common/gatt_db/macros; ../../../../../../../middleware/wireless/bluetooth_1.2.3/profiles/battery; ../../../../../../../middleware/wireless/bluetooth_1.2.3/profiles/device_info; ../../../../../../../middleware/wireless/bluetooth_1.2.3/profiles/wireless_uart; ../../../../../../../middleware/wireless/framework_5.3.3/MWSCoexistence/Interface; ../..; ../../../../../../../devices/MKW41Z4/drivers; ../../../../../../../middleware/wireless/framework_5.3.3/DCDC/Interface; ../../../../../../../middleware/wireless/framework_5.3.3/XCVR/MKW41Z4; ../../../../../../../devices/MKW41Z4; ../../../../../../../devices/MKW41Z4/utilities
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  OBJCOPY.OOCOutputFile: wireless_uart_frdmkw41z.bin
  ILINK.IlinkAdditionalLibs: ../../../../../../../middleware/wireless/bluetooth_1.2.3/host/lib/lib_ble_4-2_host_cm0p.a; ../../../../../../../middleware/wireless/bluetooth_1.2.3/controller/lib/lib_ble_kw41z_controller.a; ../../../../../../../middleware/wireless/framework_5.3.3/SecLib/lib_crypto_m0.a
  group bluetooth/controller/interface
    ../../../../../../../middleware/wireless/bluetooth_1.2.3/controller/interface/: controller_interface.h
  group bluetooth/hci_transport/interface
    ../../../../../../../middleware/wireless/bluetooth_1.2.3/hci_transport/interface/: hci_transport.h
  group bluetooth/hci_transport/source
    ../../../../../../../middleware/wireless/bluetooth_1.2.3/hci_transport/source/: hcit_serial_interface.c
  group bluetooth/host/config
    ../../../../../../../middleware/wireless/bluetooth_1.2.3/host/config/: ble_config.h ble_globals.c
  group bluetooth/host/interface
    ../../../../../../../middleware/wireless/bluetooth_1.2.3/host/interface/: att_callbacks.h att_errors.h att_interface.h att_params.h att_types.h ble_constants.h ble_general.h ble_host_tasks.h ble_sig_defines.h ble_utils.h gap_interface.h gap_types.h gatt_client_interface.h gatt_database.h gatt_db_app_interface.h gatt_db_dynamic.h gatt_interface.h gatt_server_interface.h gatt_types.h hci_interface.h hci_types.h l2ca_cb_interface.h l2ca_interface.h l2ca_types.h vendor_debug_commands.h
  group bluetooth/profiles/battery
    ../../../../../../../middleware/wireless/bluetooth_1.2.3/profiles/battery/: battery_interface.h battery_service.c
  group bluetooth/profiles/device_info
    ../../../../../../../middleware/wireless/bluetooth_1.2.3/profiles/device_info/: device_info_interface.h device_info_service.c
  group bluetooth/profiles/wireless_uart
    ../../../../../../../middleware/wireless/bluetooth_1.2.3/profiles/wireless_uart/: wireless_uart_interface.h wireless_uart_service.c
  group board
    ../: board.c board.h clock_config.c clock_config.h gpio_pins.c gpio_pins.h
  group doc
    ../../: readme.txt
  group drivers
    ../../../../../../../devices/MKW41Z4/drivers/: fsl_adc16.c fsl_adc16.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_dspi.c fsl_dspi.h fsl_flash.c fsl_flash.h fsl_gpio.c fsl_gpio.h fsl_i2c.c fsl_i2c.h fsl_llwu.c fsl_llwu.h fsl_lptmr.c fsl_lptmr.h fsl_lpuart.c fsl_lpuart.h fsl_ltc.c fsl_ltc.h fsl_pmc.c fsl_pmc.h fsl_port.h fsl_rtc.c fsl_rtc.h fsl_smc.c fsl_smc.h fsl_tpm.c fsl_tpm.h fsl_trng.c fsl_trng.h
  group framework/Common
    ../../../../../../../middleware/wireless/framework_5.3.3/Common/: EmbeddedTypes.h
  group framework/DCDC/Interface
    ../../../../../../../middleware/wireless/framework_5.3.3/DCDC/Interface/: DCDC.h
  group framework/DCDC/Source
    ../../../../../../../middleware/wireless/framework_5.3.3/DCDC/Source/: DCDC.c
  group framework/Flash/Internal
    ../../../../../../../middleware/wireless/framework_5.3.3/Flash/Internal/: Flash_Adapter.c Flash_Adapter.h
  group framework/FunctionLib
    ../../../../../../../middleware/wireless/framework_5.3.3/FunctionLib/: FunctionLib.c FunctionLib.h
  group framework/GPIO/Interface
    ../../../../../../../middleware/wireless/framework_5.3.3/GPIO/: GPIO_Adapter.h
  group framework/GPIO/Source
    ../../../../../../../middleware/wireless/framework_5.3.3/GPIO/: GPIO_Adapter.c
  group framework/Keyboard/Interface
    ../../../../../../../middleware/wireless/framework_5.3.3/Keyboard/Interface/: Keyboard.h
  group framework/Keyboard/Source
    ../../../../../../../middleware/wireless/framework_5.3.3/Keyboard/Source/: Keyboard.c
  group framework/LED/Interface
    ../../../../../../../middleware/wireless/framework_5.3.3/LED/Interface/: LED.h
  group framework/LED/Source
    ../../../../../../../middleware/wireless/framework_5.3.3/LED/Source/: LED.c
  group framework/Lists
    ../../../../../../../middleware/wireless/framework_5.3.3/Lists/: GenericList.c GenericList.h
  group framework/MemManager/Interface
    ../../../../../../../middleware/wireless/framework_5.3.3/MemManager/Interface/: MemManager.h
  group framework/MemManager/Source
    ../../../../../../../middleware/wireless/framework_5.3.3/MemManager/Source/: MemManager.c
  group framework/Messaging/Interface
    ../../../../../../../middleware/wireless/framework_5.3.3/Messaging/Interface/: Messaging.h
  group framework/Messaging/Source
    ../../../../../../../middleware/wireless/framework_5.3.3/Messaging/Source/: Messaging.c
  group framework/ModuleInfo
    ../../../../../../../middleware/wireless/framework_5.3.3/ModuleInfo/: ModuleInfo.c ModuleInfo.h
  group framework/MWSCoexistence/Interface
    ../../../../../../../middleware/wireless/framework_5.3.3/MWSCoexistence/Interface/: MWS.h
  group framework/MWSCoexistence/Source
    ../../../../../../../middleware/wireless/framework_5.3.3/MWSCoexistence/Source/: MWS.c
  group framework/NVM/Interface
    ../../../../../../../middleware/wireless/framework_5.3.3/NVM/Interface/: NVM_Interface.h
  group framework/NVM/Source
    ../../../../../../../middleware/wireless/framework_5.3.3/NVM/Source/: NV_Flash.c NV_Flash.h NV_FsciCommands.c NV_FsciCommands.h
  group framework/OSAbstraction/Interface
    ../../../../../../../middleware/wireless/framework_5.3.3/OSAbstraction/Interface/: fsl_os_abstraction.h fsl_os_abstraction_bm.h fsl_os_abstraction_config.h
  group framework/OSAbstraction/Source
    ../../../../../../../middleware/wireless/framework_5.3.3/OSAbstraction/Source/: fsl_os_abstraction_bm.c
  group framework/Panic/Interface
    ../../../../../../../middleware/wireless/framework_5.3.3/Panic/Interface/: Panic.h
  group framework/Panic/Source
    ../../../../../../../middleware/wireless/framework_5.3.3/Panic/Source/: Panic.c
  group framework/Reset/Source
    ../../../../../../../middleware/wireless/framework_5.3.3/Reset/: Reset.c
  group framework/RNG/Interface
    ../../../../../../../middleware/wireless/framework_5.3.3/RNG/Interface/: RNG_Interface.h
  group framework/RNG/Source
    ../../../../../../../middleware/wireless/framework_5.3.3/RNG/Source/: RNG.c
  group framework/SecLib
    ../../../../../../../middleware/wireless/framework_5.3.3/SecLib/: SecLib.c SecLib.h
  group framework/SerialManager/Interface
    ../../../../../../../middleware/wireless/framework_5.3.3/SerialManager/Interface/: SerialManager.h
  group framework/SerialManager/Source
    ../../../../../../../middleware/wireless/framework_5.3.3/SerialManager/Source/: SerialManager.c UART_Adapter.c UART_Adapter.h
  group framework/Shell/Interface
    ../../../../../../../middleware/wireless/framework_5.3.3/Shell/Interface/: shell.h shell_config.h
  group framework/Shell/Source
    ../../../../../../../middleware/wireless/framework_5.3.3/Shell/Source/: shell.c shell_autocomplete.c shell_cmdhelp.c shell_cmdhist.c
  group framework/TimersManager/Interface
    ../../../../../../../middleware/wireless/framework_5.3.3/TimersManager/Interface/: TimersManager.h
  group framework/TimersManager/Source
    ../../../../../../../middleware/wireless/framework_5.3.3/TimersManager/Source/: TimersManager.c TimersManagerInternal.h TMR_Adapter.c TMR_Adapter.h
  group framework/XCVR/MKW41Z4
    ../../../../../../../middleware/wireless/framework_5.3.3/XCVR/MKW41Z4/: dbg_ram_capture.c dbg_ram_capture.h fsl_xcvr.c fsl_xcvr.h fsl_xcvr_trim.c fsl_xcvr_trim.h ifr_radio.c ifr_radio.h
    ../../../../../../../middleware/wireless/framework_5.3.3/XCVR/MKW41Z4/cfgs_kw4x_3x_2x/: fsl_xcvr_ant_config.c fsl_xcvr_ble_config.c fsl_xcvr_common_config.c fsl_xcvr_gfsk_bt_0p3_h_0p5_config.c fsl_xcvr_gfsk_bt_0p5_h_0p32_config.c fsl_xcvr_gfsk_bt_0p5_h_0p5_config.c fsl_xcvr_gfsk_bt_0p5_h_0p7_config.c fsl_xcvr_gfsk_bt_0p5_h_1p0_config.c fsl_xcvr_gfsk_bt_0p7_h_0p5_config.c fsl_xcvr_mode_datarate_config.c fsl_xcvr_msk_config.c fsl_xcvr_zgbe_config.c
  group issdk/algorithms
    ../../../../../../../middleware/issdk_1.5/algorithms/pedometer/include/libinclude/: KeynetikPedometer.h
    ../../../../../../../middleware/issdk_1.5/algorithms/pedometer/source/: pedometer.c
    ../../../../../../../middleware/issdk_1.5/algorithms/pedometer/include/: pedometer.h
  group issdk/board
    ../../../../../../../middleware/issdk_1.5/boardkit/frdm-kw41z/: frdm_kw41z.c frdm_KW41Z.h pin_mux.c pin_mux.h RTE_Device.h
    ../../../../../../../middleware/issdk_1.5/boardkit/frdm-kw41z/frdm-stbc-agmp03/: frdm_stbc_agmp03_shield.h issdk_hal.h
  group issdk/cmsis
    ../../../../../../../CMSIS/Driver/Include/: Driver_Common.h Driver_I2C.h Driver_SPI.h
    ../../../../../../../middleware/issdk_1.5/drivers/gpio/: Driver_GPIO.h
    ../../../../../../../devices/MKW41Z4/cmsis_drivers/: fsl_dspi_cmsis.c fsl_i2c_cmsis.c
  group issdk/drivers
    ../../../../../../../middleware/issdk_1.5/drivers/gpio/: gpio_driver.h
    ../../../../../../../middleware/issdk_1.5/drivers/systick/: systick_utils.h
  group issdk/interface
    ../../../../../../../middleware/issdk_1.5/sensors/: register_io_i2c.c register_io_i2c.h register_io_spi.c register_io_spi.h sensor_drv.h sensor_io_i2c.c sensor_io_i2c.h sensor_io_spi.c sensor_io_spi.h
  group issdk/sensors
    ../../../../../../../middleware/issdk_1.5/sensors/: mpl3115.h mpl3115_drv.c mpl3115_drv.h
  group source
    ../../: app_config.c gatt_db.h gatt_uuid128.h issdk_interface.h issdk_mpl3115.c issdk_wireless_uart.c wireless_uart.h
    ../: app_preinclude.h
  group source/common
    ../../../../../../../middleware/wireless/bluetooth_1.2.3/application/common/: ApplMain.c ApplMain.h ble_conn_manager.c ble_conn_manager.h ble_controller_task.c ble_controller_task_config.h ble_host_task_config.h ble_host_tasks.c ble_init.c ble_init.h ble_service_discovery.c ble_service_discovery.h ieee11073.h
  group source/common/gatt_db
    ../../../../../../../middleware/wireless/bluetooth_1.2.3/application/common/gatt_db/: gatt_database.c gatt_db_handles.h
  group source/common/gatt_db/macros
    ../../../../../../../middleware/wireless/bluetooth_1.2.3/application/common/gatt_db/macros/: gatt_alloc_x.h gatt_db_macros.h gatt_db_x_macros.h gatt_decl_x.h gatt_enum_x.h gatt_init_x.h gatt_size_x.h gatt_uuid_decl_x.h gatt_uuid_def_x.h
  group startup
    ../../../../../../../devices/MKW41Z4/iar/: startup_MKW41Z4.s
    ../../../../../../../devices/MKW41Z4/: system_MKW41Z4.c system_MKW41Z4.h
  group utilities
    ../../../../../../../devices/MKW41Z4/utilities/: fsl_debug_console.c fsl_debug_console.h
