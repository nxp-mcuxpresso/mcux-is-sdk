# IAR project K64F_Simulator_Project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK64FN1M0xxx12 Freescale MK64FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_MK64FN1M0VMD12; FRDM_K64F; FREEDOM
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\..\SDK_2.0_FRDM-K64F\CMSIS\Include; ..\..\..\..\..\SDK_2.0_FRDM-K64F\devices\MK64F12; ..\..\..\..\..\SDK_2.0_FRDM-K64F\devices\MK64F12\drivers; ..\..\..\..\..\SDK_2.0_FRDM-K64F\devices\MK64F12\utilities; ..\..\..\..\sensorsimulator; ..
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  OBJCOPY.OOCOutputFile: K64F_Simulator_Project.bin
  ILINK.IlinkOutputFile: K64F_Simulator_Project.out
  ILINK.IlinkIcfFile: MK64FN1M0xxx12_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK64FN1M0VMD12; FRDM_K64F; FREEDOM
  ICCARM.CCIncludePath2: ../../../../../SDK_2.0_FRDM-K64F/CMSIS/Include; ../../../../../SDK_2.0_FRDM-K64F/devices/MK64F12; ../../../../../SDK_2.0_FRDM-K64F/devices/MK64F12/drivers; ../../../../../SDK_2.0_FRDM-K64F/devices/MK64F12/utilities; ..
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: MK64FN1M0xxx12_flash.icf
  group board
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group drivers
    ../../../../../SDK_2.0_FRDM-K64F/devices/MK64F12/drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_gpio.c fsl_gpio.h fsl_i2c.c fsl_i2c.h fsl_lptmr.c fsl_lptmr.h fsl_port.h fsl_smc.c fsl_smc.h fsl_uart.c fsl_uart.h
  group source
    ../../../: issdk_sim_fxas21002.c issdk_sim_fxos8700.c issdk_sim_mpl3115.c issdk_sim_slave.c main.c
  group startup
    ../../../../../SDK_2.0_FRDM-K64F/devices/MK64F12/iar/: startup_MK64F12.s
    ../../../../../SDK_2.0_FRDM-K64F/devices/MK64F12/: system_MK64F12.c system_MK64F12.h
  group utilities
    ../../../../../SDK_2.0_FRDM-K64F/devices/MK64F12/utilities/: fsl_debug_console.c fsl_debug_console.h
