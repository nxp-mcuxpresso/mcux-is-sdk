# IAR project main.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL25Z128xxx4 Freescale MKL25Z128xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; CPU_MKL25Z128VLK4; FRDM_KL25Z; FREEDOM; KL25Z; SDK_OS_FREE_RTOS; KSDK_2_0_SDK
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: $PROJ_DIR$; board; ..\..\..\..\cmsis; ..\..\sources; ..\..\..\..\sensors; ..\..\..\..\..\SDK_2.2_FRDM-KL25Z\devices\MKL25Z4\drivers; ..\..\..\..\..\SDK_2.2_FRDM-KL25Z\devices\MKL25Z4; ..\..\..\..\..\SDK_2.2_FRDM-KL25Z\CMSIS\Include; ..\..\..\..\..\SDK_2.2_FRDM-KL25Z\rtos\freertos_9.0.0\Source\include; ..\..\..\..\opensource; ..\..\..\..\..\SDK_2.2_FRDM-KL25Z\devices\MKL25Z4\utilities; ..\..\..\..\boardkit\frdm-kl25z; ..\..\..\..\..\SDK_2.2_FRDM-KL25Z\middleware\issdk_1.5\cmsis_drivers; ..\..\..\..\..\SDK_2.2_FRDM-KL25Z\middleware\issdk_1.5\drivers\gpio; ..\..\..\..\..\SDK_2.2_FRDM-KL25Z\CMSIS\Driver\Include; ..\..\..\..\boardkit\frdm-kl25z\virtual_shield; ..\..\..\..\..\SDK_2.2_FRDM-KL25Z\rtos\freertos_9.0.0\Source\portable\IAR\ARM_CM0; ..\..\..\..\drivers\systick; ..\..\..\..\..\SDK_2.2_FRDM-KL25Z\devices\MKL25Z4\cmsis_drivers
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $PROJ_DIR$; ..\..\..\..\..\SDK_2.2_FRDM-KL25Z\rtos\freertos_9.0.0\Source; ..\..\..\..\..\SDK_2.2_FRDM-KL25Z\rtos\freertos_9.0.0\Source\portable; C:\Users\rmpe01\Documents\GitHub\SDK_2.2_FRDM-KL25Z\rtos\freertos_9.0.0\Source\portable\IAR\ARM_CM0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: MKL25Z128xxx4_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  group boardkit
    ../../../../boardkit/frdm-kl25z/: board.c board.h clock_config.c clock_config.h frdm_kl25z.c frdm_kl25z.h pin_mux.c pin_mux.h
    ../../../../../SDK_2.2_FRDM-KL25Z/devices/MKL25Z4/drivers/: fsl_uart.c fsl_uart.h
    ../../../../boardkit/frdm-kl25z/virtual_shield/: issdk_hal.h virtual_shield.h
  group cmsis
    ../../../../../SDK_2.2_FRDM-KL25Z/CMSIS/Driver/Include/: Driver_Common.h Driver_I2C.h
    ../../../../../SDK_2.2_FRDM-KL25Z/devices/MKL25Z4/cmsis_drivers/: fsl_i2c_cmsis.c fsl_i2c_cmsis.h
  group drivers
    ../../../../../SDK_2.2_FRDM-KL25Z/devices/MKL25Z4/drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_flash.c fsl_flash.h fsl_gpio.c fsl_gpio.h fsl_i2c.c fsl_i2c.h fsl_i2c_freertos.h fsl_lpsci.c fsl_lpsci.h fsl_pit.c fsl_pit.h fsl_port.h fsl_smc.c fsl_smc.h
    ../../../../../SDK_2.2_FRDM-KL25Z/devices/MKL25Z4/: fsl_device_registers.h
  group freertos
    ../../../../../SDK_2.2_FRDM-KL25Z/rtos/freertos_9.0.0/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../../../SDK_2.2_FRDM-KL25Z/rtos/freertos_9.0.0/Source/include/: croutine.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
  group freertos/portable
    ../../../../../SDK_2.2_FRDM-KL25Z/rtos/freertos_9.0.0/Source/portable/IAR/ARM_CM0/: fsl_tickless_systick.c port.c portasm.s portmacro.h
    ../../../../../SDK_2.2_FRDM-KL25Z/rtos/freertos_9.0.0/Source/portable/MemMang/: heap_3.c
  group sensor_fusion
    ../../sources/: approximations.c approximations.h calibration_storage.c calibration_storage.h control.h control_lpsci.c debug.c debug.h DecodeCommandBytes.c driver_FXAS21002.c driver_FXOS8700.c driver_KSDK_NVM.c driver_KSDK_NVM.h driver_MPL3115.c driver_pit.c driver_pit.h driver_systick.c drivers.h fusion.c fusion.h hal_frdm_fxs_mult2_b.c magnetic.c magnetic.h main_freertos_two_tasks.c matrix.c matrix.h orientation.c orientation.h output_stream.c precisionAccelerometer.c precisionAccelerometer.h sensor_fusion.c sensor_fusion.h status.c status.h
  group sensors
    ../../../../sensors/: fxas21002.h fxos8700.h mpl3115.h register_io_i2c.c register_io_i2c.h sensor_drv.h sensor_io_i2c.c sensor_io_i2c.h
  group source
    ./: build.h FreeRTOSConfig.h
  group startup
    ../../../../../SDK_2.2_FRDM-KL25Z/devices/MKL25Z4/iar/: startup_MKL25Z4.s
    ../../../../../SDK_2.2_FRDM-KL25Z/devices/MKL25Z4/: system_MKL25Z4.c system_MKL25Z4.h
  group utilities
    ../../../../../SDK_2.2_FRDM-KL25Z/devices/MKL25Z4/utilities/: fsl_debug_console.c fsl_debug_console.h
