# IAR project main.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC54114J256_M4 NXP LPC54114J256_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_LPC54114J256BD64_cm4; SDK_OS_FREE_RTOS
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\..\SDK_2.2_LPCXpresso54114\rtos\freertos_9.0.0\Source\portable\IAR\ARM_CM4F; ..\..\..\..\..\..\..\SDK_2.2_LPCXpresso54114\rtos\freertos_9.0.0\Source\include; ..\..\..\..\..\..\..\SDK_2.2_LPCXpresso54114\CMSIS\Include; ..\..\..\..\..\..\..\SDK_2.2_LPCXpresso54114\devices; ..\..\..\..\..\..\..\SDK_2.2_LPCXpresso54114\devices\LPC54114; ..\..\..\..\..\..\..\SDK_2.2_LPCXpresso54114\boards\lpcxpresso54114; ..\..\..\..\..\..\..\SDK_2.2_LPCXpresso54114\boards\lpcxpresso54114\rtos_examples\main; ..\..\..\..\..\..\..\SDK_2.2_LPCXpresso54114\rtos\freertos_9.0.0\Source; ..\..\..\..\..\..\..\SDK_2.2_LPCXpresso54114\devices\LPC54114\utilities; ..\..\..\..\..\..\..\SDK_2.2_LPCXpresso54114\devices\LPC54114\drivers; ..\..; ..\..\..\..\..\..\drivers\gpio; ..\..\..\..\..\..\..\SDK_2.2_LPCXpresso54114\CMSIS\Driver\Include; ..\..\..\..\..\..\drivers\gpio\lpc; ..\..\..\..\..\..\drivers\systick; ..\..\..\..\..\..\..\SDK_2.2_LPCXpresso54114\devices\LPC54114\cmsis_drivers; ..\..\..\..\..\..\boardkit\lpcxpresso54114; ..\..\..\..\..\..\boardkit\lpcxpresso54114\frdm-stbc-agm01; ..\..\..\..\..\..\boardkit\lpcxpresso54114; ..\..\..\..\..\..\sensors
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\..\..\..\..\SDK_2.2_LPCXpresso54114\boards\lpcxpresso54114\rtos_examples\main; ..\..\..\..\..\..\..\SDK_2.2_LPCXpresso54114\boards\lpcxpresso54114; ..\..
  ILINK.IlinkOutputFile: main.out
  ILINK.IlinkIcfFile: LPC54114J256_cm4.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\..\SDK_2.2_LPCXpresso54114\devices\LPC54114\iar\iar_lib_power.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_LPC54114J256BD64_cm4; SDK_OS_FREE_RTOS
  ICCARM.CCIncludePath2: ../../../../../../rtos/freertos_9.0.0/Source/portable/IAR/ARM_CM4F; ../../../../../../rtos/freertos_9.0.0/Source/include; ../../../../../../CMSIS/Include; ../../../../../../devices; ../../../../../../devices/LPC54114; ../../../..; ../..; ../../../../../../rtos/freertos_9.0.0/Source; ../../../../../../devices/LPC54114/drivers; ../../../../../../devices/LPC54114/utilities
  AARM.AUserIncludes: ../..; ../../../..
  ILINK.IlinkAdditionalLibs: ../../../../../../devices/LPC54114/iar/iar_lib_power.a
  group boardkit
    ../../../../../../boardkit/lpcxpresso54114/: board.c board.h clock_config.c clock_config.h lpc54114.c lpc54114.h pin_mux.c pin_mux.h RTE_Device.h
    ../../../../../../boardkit/lpcxpresso54114/frdm-stbc-agm01/: frdm_stbc_agm01_shield.h issdk_hal.h
  group cmsis
    ../../../../../../../SDK_2.2_LPCXpresso54114/CMSIS/Driver/Include/: Driver_Common.h Driver_I2C.h
    ../../../../../../../SDK_2.2_LPCXpresso54114/devices/LPC54114/cmsis_drivers/: fsl_i2c_cmsis.c fsl_i2c_cmsis.h
  group doc
    ../../: readme.txt
  group drivers
    ../../../../../../../SDK_2.2_LPCXpresso54114/devices/LPC54114/drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_flashiap.c fsl_flashiap.h fsl_flexcomm.c fsl_flexcomm.h fsl_gpio.c fsl_gpio.h fsl_i2c.c fsl_i2c.h fsl_inputmux.c fsl_inputmux.h fsl_iocon.h fsl_power.c fsl_reset.c fsl_reset.h fsl_usart.c fsl_usart.h
  group freertos
    ../../../../../../../SDK_2.2_LPCXpresso54114/rtos/freertos_9.0.0/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../../../../../SDK_2.2_LPCXpresso54114/rtos/freertos_9.0.0/Source/include/: croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
  group freertos/portable
    ../../../../../../../SDK_2.2_LPCXpresso54114/rtos/freertos_9.0.0/Source/portable/IAR/ARM_CM4F/: fsl_tickless_generic.h fsl_tickless_systick.c port.c portasm.s portmacro.h
    ../../../../../../../SDK_2.2_LPCXpresso54114/rtos/freertos_9.0.0/Source/portable/MemMang/: heap_1.c
  group sensor_fusion
    ../../../../sources/: approximations.c approximations.h calibration_storage.c calibration_storage.h control.h control_lpc.c debug.c debug.h DecodeCommandBytes.c driver_FXAS21002.c driver_FXOS8700.c driver_KSDK_NVM.c driver_KSDK_NVM.h driver_systick.c drivers.h fusion.c fusion.h hal_frdm_fxs_mult2_b.c magnetic.c magnetic.h matrix.c matrix.h orientation.c orientation.h output_stream.c precisionAccelerometer.c precisionAccelerometer.h sensor_fusion.c sensor_fusion.h status.c status.h
  group sensors
    ../../../../../../sensors/: fxas21002.h fxos8700.h register_io_i2c.c register_io_i2c.h sensor_drv.h sensor_io_i2c.c sensor_io_i2c.h
  group source
    ../../: build.h FreeRTOSConfig.h
    ../../../../sources/: main_agm01_freertos_two_tasks.c
  group startup
    ../../../../../../../SDK_2.2_LPCXpresso54114/devices/LPC54114/iar/: startup_LPC54114_cm4.s
    ../../../../../../../SDK_2.2_LPCXpresso54114/devices/LPC54114/: system_LPC54114_cm4.c system_LPC54114_cm4.h
  group utilities
    ../../../../../../../SDK_2.2_LPCXpresso54114/devices/LPC54114/utilities/: fsl_debug_console.c fsl_debug_console.h
