# IAR project main.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK22FN512xxx12 Freescale MK22FN512xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_MK22FN512VLH12; FRDM_K22F; FREEDOM; K22F; SDK_OS_FREE_RTOS; KSDK_2_0_SDK
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\..\..\..\cmsis; ..\..\sources; ..\..\..\..\sensors; ..\..\..\..\..\SDK_2.2_FRDM-K22F\devices\MK22F51212\drivers; ..\..\..\..\..\SDK_2.2_FRDM-K22F\devices\MK22F51212; ..\..\..\..\..\SDK_2.2_FRDM-K22F\CMSIS\Include; ..\..\..\..\..\SDK_2.2_FRDM-K22F\rtos\freertos_9.0.0\Source\include; ..\..\..\..\opensource; ..\..\..\..\..\SDK_2.2_FRDM-K22F\rtos\freertos_9.0.0\Source\portable\IAR\ARM_CM4F; ..\..\..\..\..\SDK_2.2_FRDM-K22F\devices\MK22F51212\utilities; ..\..\..\..\boardkit\frdm-k22f; ..\..\..\..\..\SDK_2.2_FRDM-K22F\middleware\issdk_1.5\cmsis_drivers; ..\..\..\..\..\SDK_2.2_FRDM-K22F\CMSIS\Driver\Include; ..\..\..\..\..\SDK_2.2_FRDM-K22F\middleware\issdk_1.5; ..\..\..\..\drivers\systick; ..\..\..\..\boardkit\frdm-k22f\frdm-stbc-agmp03; ..\..\..\..\..\SDK_2.2_FRDM-K22F\devices\MK22F51212\cmsis_drivers; ..\..\..\..\drivers\gpio\kinetis; ..\..\..\..\drivers\gpio
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $PROJ_DIR$; ..\..\..\..\..\SDK_2.2_FRDM-K22F\rtos\freertos_9.0.0\Source; ..\..\..\..\..\SDK_2.2_FRDM-K22F\rtos\freertos_9.0.0\Source\portable; ..\..\..\..\..\SDK_2.2_FRDM-K22F\rtos\freertos_9.0.0\Source\portable\IAR\ARM_CM4F
  OBJCOPY.OOCOutputFile: main.srec
  ILINK.IlinkOutputFile: c.bin
  ILINK.IlinkIcfFile: MK22FN512xxx12_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  group boardkit
    ../../../../boardkit/frdm-k22f/: board.c board.h clock_config.c clock_config.h frdm_k22f.c frdm_k22f.h pin_mux.c pin_mux.h
    ../../../../boardkit/frdm-k22f/frdm-stbc-agmp03/: frdm_stbc_agmp03_shield.h issdk_hal.h
  group cmsis
    ../../../../../SDK_2.2_FRDM-K22F/CMSIS/Driver/Include/: Driver_Common.h Driver_I2C.h
    ../../../../../SDK_2.2_FRDM-K22F/devices/MK22F51212/cmsis_drivers/: fsl_i2c_cmsis.c fsl_i2c_cmsis.h
  group drivers
    ../../../../../SDK_2.2_FRDM-K22F/devices/MK22F51212/drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_flash.c fsl_flash.h fsl_gpio.c fsl_gpio.h fsl_i2c.c fsl_i2c.h fsl_i2c_freertos.h fsl_lpuart.c fsl_lpuart.h fsl_pit.c fsl_pit.h fsl_port.h fsl_smc.c fsl_smc.h fsl_uart.c fsl_uart.h
    ../../../../../SDK_2.2_FRDM-K22F/devices/MK22F51212/: fsl_device_registers.h
  group freertos
    ../../../../../SDK_2.2_FRDM-K22F/rtos/freertos_9.0.0/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../../../SDK_2.2_FRDM-K22F/rtos/freertos_9.0.0/Source/include/: croutine.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
    ../../../../../SDK_2.2_FRDM-K22F/rtos/freertos_9.0.0/Source/portable/IAR/ARM_CM4F/: fsl_tickless_systick.c
  group freertos/portable
    ../../../../../SDK_2.2_FRDM-K22F/rtos/freertos_9.0.0/Source/portable/MemMang/: heap_1.c
    ../../../../../SDK_2.2_FRDM-K22F/rtos/freertos_9.0.0/Source/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group sensor_fusion
    ../../sources/: approximations.c approximations.h calibration_storage.c calibration_storage.h control.c control.h debug.c debug.h DecodeCommandBytes.c driver_FXAS21002.c driver_FXLS8962.c driver_KSDK_NVM.c driver_KSDK_NVM.h driver_MAG3110.c driver_MPL3115.c driver_pit.c driver_pit.h driver_systick.c drivers.h fusion.c fusion.h hal_frdm_fxs_mult2_b.c hal_frdm_fxs_mult2_b.h hal_frdm_k22f.h magnetic.c magnetic.h main_agmp03_freertos_two_tasks.c matrix.c matrix.h orientation.c orientation.h output_stream.c precisionAccelerometer.c precisionAccelerometer.h sensor_fusion.c sensor_fusion.h status.c status.h
  group sensors
    ../../../../sensors/: fxas21002.h fxls8962.h mag3110.h mpl3115.h register_io_i2c.c register_io_i2c.h sensor_drv.h sensor_io_i2c.c sensor_io_i2c.h
  group source
    ./: build.h FreeRTOSConfig.h
  group startup
    ../../../../../SDK_2.2_FRDM-K22F/devices/MK22F51212/iar/: startup_MK22F51212.s
    ../../../../../SDK_2.2_FRDM-K22F/devices/MK22F51212/: system_MK22F51212.c system_MK22F51212.h
  group utilities
    ../../../../../SDK_2.2_FRDM-K22F/devices/MK22F51212/utilities/: fsl_debug_console.c fsl_debug_console.h
