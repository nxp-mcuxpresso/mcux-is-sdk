# IAR project main.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC54114J256_M4 NXP LPC54114J256_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_LPC54114J256BD64_cm4; SDK_OS_FREE_RTOS
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\..\SDK_2.2_LPCXpresso54114\rtos\freertos_9.0.0\Source\portable\IAR\ARM_CM4F; ..\..\..\..\..\..\..\SDK_2.2_LPCXpresso54114\rtos\freertos_9.0.0\Source\include; ..\..\..\..\..\..\..\SDK_2.2_LPCXpresso54114\CMSIS\Include; ..\..\..\..\..\..\..\SDK_2.2_LPCXpresso54114\devices; ..\..\..\..\..\..\..\SDK_2.2_LPCXpresso54114\devices\LPC54114; ..\..\..\..\..\..\..\SDK_2.2_LPCXpresso54114\boards\lpcxpresso54114; ..\..\..\..\..\..\..\SDK_2.2_LPCXpresso54114\boards\lpcxpresso54114\rtos_examples\main; ..\..\..\..\..\..\..\SDK_2.2_LPCXpresso54114\rtos\freertos_9.0.0\Source; ..\..\..\..\..\..\..\SDK_2.2_LPCXpresso54114\devices\LPC54114\utilities; ..\..\..\..\..\..\..\SDK_2.2_LPCXpresso54114\devices\LPC54114\drivers; ..\..
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\..\..\..\..\SDK_2.2_LPCXpresso54114\boards\lpcxpresso54114\rtos_examples\main; ..\..\..\..\..\..\..\SDK_2.2_LPCXpresso54114\boards\lpcxpresso54114; ..\..
  ILINK.IlinkOutputFile: main.out
  ILINK.IlinkIcfFile: LPC54114J256_cm4.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\..\SDK_2.2_LPCXpresso54114\devices\LPC54114\iar\iar_lib_power.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_LPC54114J256BD64_cm4; SDK_OS_FREE_RTOS
  ICCARM.CCIncludePath2: ../../../../../../rtos/freertos_9.0.0/Source/portable/IAR/ARM_CM4F; ../../../../../../rtos/freertos_9.0.0/Source/include; ../../../../../../CMSIS/Include; ../../../../../../devices; ../../../../../../devices/LPC54114; ../../../..; ../..; ../../../../../../rtos/freertos_9.0.0/Source; ../../../../../../devices/LPC54114/drivers; ../../../../../../devices/LPC54114/utilities
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: ../..; ../../../..
  ILINK.IlinkAdditionalLibs: ../../../../../../devices/LPC54114/iar/iar_lib_power.a
  group board
    ../../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group doc
    ../../: readme.txt
  group drivers
    ../../../../../../../SDK_2.2_LPCXpresso54114/devices/LPC54114/drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_flexcomm.c fsl_flexcomm.h fsl_gpio.c fsl_gpio.h fsl_inputmux.c fsl_inputmux.h fsl_iocon.h fsl_power.c fsl_reset.c fsl_reset.h fsl_usart.c fsl_usart.h
  group freertos
    ../../../../../../../SDK_2.2_LPCXpresso54114/rtos/freertos_9.0.0/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../../../../../SDK_2.2_LPCXpresso54114/rtos/freertos_9.0.0/Source/include/: croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h freertos_tasks_c_additions.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
    ../../../../../../../SDK_2.2_LPCXpresso54114/rtos/freertos_9.0.0/Source/portable/MemMang/: heap_4.c
  group freertos/portable
    ../../../../../../../SDK_2.2_LPCXpresso54114/rtos/freertos_9.0.0/Source/portable/IAR/ARM_CM4F/: fsl_tickless_generic.h fsl_tickless_systick.c port.c portasm.s portmacro.h
  group source
    ../../: FreeRTOSConfig.h main.c
  group startup
    ../../../../../../../SDK_2.2_LPCXpresso54114/devices/LPC54114/iar/: startup_LPC54114_cm4.s
    ../../../../../../../SDK_2.2_LPCXpresso54114/devices/LPC54114/: system_LPC54114_cm4.c system_LPC54114_cm4.h
  group utilities
    ../../../../../../../SDK_2.2_LPCXpresso54114/devices/LPC54114/utilities/: fsl_debug_console.c fsl_debug_console.h
