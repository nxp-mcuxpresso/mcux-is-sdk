# IAR project main.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK64FN1M0xxx12 Freescale MK64FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_MK64FN1M0VMD12; FRDM_K64F; FREEDOM; K64F; SDK_OS_FREE_RTOS; KSDK_2_0_SDK
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: $PROJ_DIR$; board; ..\..\..\..\cmsis; ..\..\sources; ..\..\..\..\sensors; ..\..\..\..\..\SDK_2.1_FRDM-K64F\devices\MK64F12\drivers; ..\..\..\..\..\SDK_2.1_FRDM-K64F\devices\MK64F12; ..\..\..\..\..\SDK_2.1_FRDM-K64F\CMSIS\Include; ..\..\..\..\..\SDK_2.1_FRDM-K64F\rtos\freertos_9.0.0\Source\include; ..\..\..\..\opensource; ..\..\..\..\..\SDK_2.1_FRDM-K64F\rtos\freertos_9.0.0\Source\portable\IAR\ARM_CM4F; ..\..\..\..\..\SDK_2.1_FRDM-K64F\devices\MK64F12\utilities; ..\..\..\..\boardkit\frdm-k64f; ..\..\..\..\boardkit\frdm-k64f\frdm-stbc-agm02; ..\..\..\..\..\SDK_2.1_FRDM-K64F\middleware\issdk_1.0\cmsis_drivers; ..\..\..\..\..\SDK_2.1_FRDM-K64F\middleware\issdk_1.0\drivers\gpio; ..\..\..\..\..\SDK_2.1_FRDM-K64F\CMSIS\Driver\Include; ..\..\..\..\drivers\systick; ..\..\..\..\..\SDK_2.1_FRDM-K64F\devices\MK64F12\cmsis_drivers
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $PROJ_DIR$; ..\..\..\..\..\SDK_2.1_FRDM-K64F\rtos\freertos_9.0.0\Source; ..\..\..\..\..\SDK_2.1_FRDM-K64F\rtos\freertos_9.0.0\Source\portable; ..\..\..\..\..\SDK_2.1_FRDM-K64F\rtos\freertos_9.0.0\Source\portable\IAR\ARM_CM4F
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: MK64FN1M0xxx12_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  group boardkit
    ../../../../boardkit/frdm-k64f/: board.c board.h clock_config.c clock_config.h frdm_k64f.c frdm_k64f.h pin_mux.c pin_mux.h
    ../../../../boardkit/frdm-k64f/frdm-stbc-agm02/: frdm_stbc_agm02_shield.h issdk_hal.h
  group cmsis
    ../../../../../SDK_2.1_FRDM-K64F/CMSIS/Driver/Include/: Driver_Common.h Driver_I2C.h
    ../../../../../SDK_2.1_FRDM-K64F/devices/MK64F12/cmsis_drivers/: fsl_i2c_cmsis.c fsl_i2c_cmsis.h
  group drivers
    ../../../../../SDK_2.1_FRDM-K64F/devices/MK64F12/drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_gpio.c fsl_gpio.h fsl_i2c.c fsl_i2c.h fsl_i2c_freertos.h fsl_pit.c fsl_pit.h fsl_port.h fsl_smc.c fsl_smc.h fsl_uart.c fsl_uart.h
    ../../../../../SDK_2.1_FRDM-K64F/devices/MK64F12/: fsl_device_registers.h
  group freertos
    ../../../../../SDK_2.1_FRDM-K64F/rtos/freertos_9.0.0/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../../../SDK_2.1_FRDM-K64F/rtos/freertos_9.0.0/Source/include/: croutine.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
    ../../../../../SDK_2.1_FRDM-K64F/rtos/freertos_9.0.0/Source/portable/IAR/ARM_CM4F/: fsl_tickless_systick.c
  group freertos/portable
    ../../../../../SDK_2.1_FRDM-K64F/rtos/freertos_9.0.0/Source/portable/MemMang/: heap_1.c
    ../../../../../SDK_2.1_FRDM-K64F/rtos/freertos_9.0.0/Source/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group sensor_fusion
    ../../sources/: approximations.c approximations.h calibration_storage.c calibration_storage.h control.c control.h debug.c debug.h DecodeCommandBytes.c driver_FXAS21002.c driver_FXLS8952.c driver_KSDK_NVM.c driver_KSDK_NVM.h driver_MAG3110.c driver_pit.c driver_pit.h driver_systick.c drivers.h fusion.c fusion.h hal_frdm_fxs_mult2_b.c magnetic.c magnetic.h main_freertos_agm02_power_cycling.c matrix.c matrix.h motionCheck.c orientation.c orientation.h output_stream.c precisionAccelerometer.c precisionAccelerometer.h sensor_fusion.c sensor_fusion.h status.c status.h
  group sensors
    ../../../../../SDK_2.1_FRDM-K64F/devices/MK64F12/drivers/: fsl_flash.c fsl_flash.h
    ../../../../sensors/: fxas21002.h fxls8952.h mag3110.h mpl3115.h register_io_i2c.c register_io_i2c.h sensor_drv.h sensor_io_i2c.c sensor_io_i2c.h
  group source
    ./: build.h FreeRTOSConfig.h
  group startup
    ../../../../../SDK_2.1_FRDM-K64F/devices/MK64F12/iar/: startup_MK64F12.s
    ../../../../../SDK_2.1_FRDM-K64F/devices/MK64F12/: system_MK64F12.c system_MK64F12.h
  group utilities
    ../../../../../SDK_2.1_FRDM-K64F/devices/MK64F12/utilities/: fsl_debug_console.c fsl_debug_console.h
