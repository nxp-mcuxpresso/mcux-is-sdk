# IAR project main.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK66FN2M0xxx18 Freescale MK66FN2M0xxx18
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_MK66FN2M0VMD18; SDK_OS_FREE_RTOS; FRDM_K66F; FREEDOM; PRINTF_FLOAT_ENABLE=1
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ..\..\..\..\..\..\SDK_2.1_FRDM-K66F\devices; ..\..\..\..\..\..\SDK_2.1_FRDM-K66F\devices\MK66F18; ..\..\..\..\..\..\SDK_2.1_FRDM-K66F\devices\MK66F18\drivers; ..\..\..\..\..\..\SDK_2.1_FRDM-K66F\devices\MK66F18\utilities; ..\..\..\..\..\..\SDK_2.1_FRDM-K66F\rtos\freertos_9.0.0\Source; ..\..\..\..\..\..\SDK_2.1_FRDM-K66F\rtos\freertos_9.0.0\Source\include; ..\..\..\..\..\..\SDK_2.1_FRDM-K66F\rtos\freertos_9.0.0\Source\portable\IAR\ARM_CM4F; ..\..\..\..\..\..\SDK_2.1_FRDM-K66F\CMSIS\Include; ..\..\..\..\..\cmsis_drivers; ..\..\..\..\..\boardkit\frdm-k66f\baseboard; ..\..\..\..\..\boardkit\frdm-k66f; ..\..\..\..\..\drivers\gpio; ..\..\..\..\..\sensors; ..\..\..\..\..\..\SDK_2.1_FRDM-K66F\devices\MK66F18\cmsis_drivers; ..\..\..\..\..\drivers\systick; ..\..\..\..\..\..\SDK_2.1_FRDM-K66F\CMSIS\Driver\Include; ..\..\..\..\..\drivers\host; ..\..\..\sources; ..\..\..\..\..\drivers\gpio\kinetis
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: ..
  ILINK.IlinkOutputFile: main.out
  ILINK.IlinkIcfFile: MK66FN2M0xxx18_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK66FN2M0VMD18; SDK_OS_FREE_RTOS; FRDM_K66F; FREEDOM
  ICCARM.CCIncludePath2: ../../../../../rtos/freertos_9.0.0/Source/portable/IAR/ARM_CM4F; ../../../../../rtos/freertos_9.0.0/Source/include; ../../../../../CMSIS/Include; ../../../../../devices; ../../../../../devices/MK66F18/drivers; ..; ../../../../../devices/MK66F18/utilities; ../../../../../rtos/freertos_9.0.0/Source; ../../..; ../../../../../devices/MK66F18
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group anomaly_detection
    ../../../sources/: anomaly_detection.c anomaly_detection.h approximations.c approximations.h calibration_storage.c calibration_storage.h control.c control.h driver_FXAS21002.c driver_FXOS8700.c driver_KSDK_NVM.c driver_KSDK_NVM.h driver_pit.c driver_pit.h driver_systick.c drivers.h fsl_dialog7212.c fsl_dialog7212.h gmm_utility.c gmm_utility.h machineLearning_subsystem.c machineLearning_subsystem.h matrix.c matrix.h orientation.c orientation.h output_stream.c output_stream.h process_host_command.c sai_interrupt.c sai_interrupt.h status.c status.h svm.cpp svm.h
  group boardkit
    ../../../../../boardkit/frdm-k66f/: board.c board.h clock_config.c clock_config.h frdm_k66f.c frdm_k66f.h pin_mux.c pin_mux.h
    ../../../../../boardkit/frdm-k66f/baseboard/: issdk_hal.h
  group doc
    ../: readme.txt
  group issdk/drivers/gpio
    ../../../../../drivers/gpio/: Driver_GPIO.h
    ../../../../../drivers/gpio/kinetis/: gpio_driver.c gpio_driver.h gpio_driver_irq.c
  group issdk/drivers/host
    ../../../../../drivers/host/: comm_if_uart.c comm_interface.h data_format_hdlc.c data_format_hdlc.h data_format_json.c data_format_json.h data_format_service.h host_interface_service.c host_interface_service.h
  group issdk/sensors
    ../../../../../sensors/: fxas21002.h fxos8700.h host_io_uart.c host_io_uart.h register_io_i2c.c register_io_i2c.h register_io_spi.c register_io_spi.h sensor_drv.h sensor_io_i2c.c sensor_io_i2c.h
    ../../../../../drivers/systick/: systick_utils.h
  group sdk/cmsis
    ../../../../../../SDK_2.1_FRDM-K66F/CMSIS/Driver/Include/: Driver_Common.h Driver_I2C.h
  group sdk/drivers
    ../../../../../../SDK_2.1_FRDM-K66F/devices/MK66F18/drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_dmamux.c fsl_dmamux.h fsl_flash.c fsl_flash.h fsl_gpio.c fsl_gpio.h fsl_i2c.c fsl_i2c.h fsl_lpuart.c fsl_lpuart.h fsl_pit.c fsl_pit.h fsl_port.h fsl_sai.c fsl_sai.h fsl_smc.c fsl_smc.h fsl_uart.c fsl_uart.h
    ../../../../../../SDK_2.1_FRDM-K66F/devices/MK66F18/: fsl_device_registers.h
    ../../../../../../SDK_2.1_FRDM-K66F/devices/MK66F18/cmsis_drivers/: fsl_i2c_cmsis.c fsl_i2c_cmsis.h fsl_uart_cmsis.c fsl_uart_cmsis.h
  group sdk/freertos
    ../../../../../../SDK_2.1_FRDM-K66F/rtos/freertos_9.0.0/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../../../../SDK_2.1_FRDM-K66F/rtos/freertos_9.0.0/Source/include/: croutine.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
    ../../../../../../SDK_2.1_FRDM-K66F/rtos/freertos_9.0.0/Source/portable/IAR/ARM_CM4F/: fsl_tickless_systick.c
    ../../../../../../SDK_2.1_FRDM-K66F/rtos/freertos_9.0.0/Source/portable/MemMang/: heap_4.c
  group sdk/freertos/portable
    ../../../../../../SDK_2.1_FRDM-K66F/rtos/freertos_9.0.0/Source/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group sdk/startup
    ../../../../../../SDK_2.1_FRDM-K66F/devices/MK66F18/iar/: startup_MK66F18.s
    ../../../../../../SDK_2.1_FRDM-K66F/devices/MK66F18/: system_MK66F18.c system_MK66F18.h
  group sdk/utilities
    ../../../../../../SDK_2.1_FRDM-K66F/devices/MK66F18/utilities/: fsl_debug_console.c fsl_debug_console.h
  group source
    ../: build.h FreeRTOSConfig.h main.c RTE_Device.h
